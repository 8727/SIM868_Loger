# Keil uVision project v1.1.uvprojx, settings and files
target RTOS_SIM868_Loger_v1 (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.5.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: v1.1 +hex
  c flags: OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\SIM868_Loger;..\SOURCE\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Source
    ../SOURCE/src/: main.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.3.1
